Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-01-30T15:14:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 30 15:14:40 2024 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\f24a711b-3b8c-41de-896d-9c90fd1cefdb\d9cd0485-74e3-4e05-86d1-a0a1aeb5727a\ifc * Database version: 5507 * Database creation date: Tue Jan 30 15:14:39 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jan 30 15:14:39 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 30 15:14:39 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 9262FMZ Washbasin faucet, 9/230 V, Bluetooth, 9262FMZ(2024):9262FMZ Washbasin faucet, 9/230 V, Bluetooth:366881
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 167.926 mm; FaucetNominalHeight: 136 mm; FaucetNominalWidth: 70.9541 mm; HandShowerNominalDepth: 65.3967 mm; HandShowerNominalHeight: 421.074 mm; HandShowerNominalWidth: 56.8083 mm; InletConnectionSize: 8 mm
Type - Electrical - Battery: AA 1.5 V Lithium x 2, CR 2450 3 V; Bluetooth: 5.x (D060576); Electrical Connection: 9 V; Operating Voltage: 39 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 9262FMZ(2024); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Washbasin faucet with Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150105166; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; Noise Class: I (ISO 3822); URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/9262FMZ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/9262FMZ; URL WEEE: http://static.oras.com/WEEE/9262FMZ
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/9262FMZ; Catalog Drawing URL: http://static.oras.com/catdrw/9262FMZ; Dimension Drawing URL: http://static.oras.com/dimdrw/9262FMZ; FDV Document URL: http://www.oras.com/datasheet/9262FMZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/9262FMZ; Group: Washbasin faucet; Long Marketing: Bluetooth Touchless faucet. Easy grip temperature lever for good grip and easy adjustment. SMART intelligent bluetooth sensor with 3 optical lenses for improved performance supported by app connection for personalized and easy adjustment of sensor settings. SMART Remote disinfection proof bidetta Intelligent temperature measurement and intelligent Antiscalding protection. Brass casted construction and easy installation due to fast and easy 3S installation system.; Manufacturer: Oras; Market: International;Finland; Mobile Product Information URL: http://mpi.oras.com/9262FMZ; Model: 9262FMZ Washbasin faucet, 9/230 V, Bluetooth; Name_en: 9262FMZ Washbasin faucet, 9/230 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 9262FMZ; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/9262FMZ; Product URL: http://static.oras.com/9262FMZ; Short Marketing: Electra 92 series give you a clean classic design with beautiful round body flowing into round spout design with a clear design line framing the faucet design. A Classic design for any installation. Key Features Aerator with Tilt function +/- 10° for more flexible installation Newest Sensor technology for better detection and operation comfort Bluetooth technology for easy adjustment to personalize settings Antiscalding protection Temperature measurement Bluetooth Remote disinfection proof bidetta Handshower Power transformer and power cable; Technical DataSheet URL: http://www.oras.com/datasheet/9262FMZ/en; Type Name: 9262FMZ Washbasin faucet, 9/230 V, Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;3S-installation system for safe and simple mounting; Aerator: Laminar stream; Afterflow Period: 3 s (1-20 s); Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Backflow Prevention EN1717: EB; Connection: Flexible inlet pipes; Connection Size: G3/8; Electronic Parts: ;Light indicated function(s);Low battery indicator; Flow Rate At 300kPa With Flow Controller: 0.00317832 m3/s; Hand Shower: Remote-operated Smart Bidetta; Installation Type: Deck mounted; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 2 min (1 - 1800 s); Mechanical Parts: Mixing valve for manual temperature control;Non-return valve(s);Litter filter(s); Mounting Holes: 1 hole; Operating Distance: 20-130 mm (110/130/160 mm); Pressure Loss With Flow 01ls: 375000 Pa; Shower Parts: Hand shower;Shower holder;Shower hose (1500 mm); Spout Projection: 123 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Temperature limiter; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 9262FMZ(2024); Features: Bluetooth®; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 9262FMZ; Name: 9262FMZ Washbasin faucet, 9/230 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x155x140 mm / Hand shower: 46x64x286 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 9262FMZ Washbasin faucet, 9/230 V, Bluetooth; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 9262FMZ; Manufacturer: Oras
Pset_ProductRequirements - Name: 9262FMZ Washbasin faucet, 9/230 V, Bluetooth; Category: Plumbing Fixtures
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0452572 m2; Volume: 0.00162346 m3
Identity Data - Mark: 6
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 9262FMZ(2024): 9262FMZ Washbasin faucet, 9/230 V, Bluetooth; Family and Type: 9262FMZ(2024): 9262FMZ Washbasin faucet, 9/230 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 9262FMZ(2024): 9262FMZ Washbasin faucet, 9/230 V, Bluetooth; Type Id: 9262FMZ(2024): 9262FMZ Washbasin faucet, 9/230 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
